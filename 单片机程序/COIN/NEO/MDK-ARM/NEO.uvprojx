# Keil uVision project NEO.uvprojx, settings and files
target NEO (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: NEO +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\NEO\NEO.bin .\OBJ\NEO.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Algorithm;..\STM32_Cryptographic_Library\inc;..\ATSHA204\Appatsha204;..\ATSHA204\Atsha204_hw;..\ATSHA204\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8060000 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Algorithm
    ../Algorithm/: bignum.c ecdsa.c getaddress.c ripemd160.c showsign.c stmflash.c Sha256.lib app_aes.c app_des.c
  group APP
    ../ATSHA204/Appatsha204/: atsha204a.c
    ../Src/: app_interface.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c sys.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c
  group CryptoAuthlib
    ../ATSHA204/lib/: atca_command.c
    ../ATSHA204/lib/basic/: atca_basic.c
    ../ATSHA204/lib/crypto/: atca_crypto_sw_sha2.c
    ../ATSHA204/lib/crypto/hashes/: sha2_routines.c
    ../ATSHA204/lib/host/: atca_host.c
  group ATSHA204iface
    ../ATSHA204/lib/iface/: atca_iface_stm32_i2c.c atca_iface_stm32_swi.c
    ../ATSHA204/lib/hal/: hal_stm32_timer.c
    ../ATSHA204/Atsha204_hw/: bitBang_i2c.c
software components: CMSIS:CORE 4.1.0
