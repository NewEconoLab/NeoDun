# Keil uVision project NEO.uvprojx, settings and files
target NEO (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NEO +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\OBJ\neo.bin .\OBJ\neo.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\ENCRYPT;..\STM32_Cryptographic_Library\inc;..\HARDWARE\SHOWSIGN;..\HARDWARE\GETADDRESS;..\HARDWARE\BIGNUM;..\HARDWARE\RIPEMD160;..\HARDWARE\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8060000 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_cryp.c stm32f4xx_dma.c stm32f4xx_hash.c stm32f4xx_rng.c stm32f4xx_crc.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/ENCRYPT/: encrypt.c
    ../HARDWARE/SHOWSIGN/: showsign.c
    ../HARDWARE/GETADDRESS/: getaddress.c
    ../HARDWARE/BIGNUM/: bignum.c
    ../HARDWARE/RIPEMD160/: ripemd160.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group Lib
    ../STM32_Cryptographic_Library/binary/MK-ARM/: M4_CryptoFW_RngHW_2_0_6.lib
  group README
    ../README/: readme.txt
