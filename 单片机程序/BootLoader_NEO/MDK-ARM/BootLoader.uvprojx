# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: BootLoader_NEO +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\ATSHA204\Appatsha204;..\ATSHA204\Atsha204_hw;..\ATSHA204\lib;..\STM32_Cryptographic_Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group APP
    ../Src/: app_interface.c app_command.c app_ecdsa.c.c main_define.c
  group ATSHA204_HW
    ../ATSHA204/Atsha204_hw/: bitBang_i2c.c hw_config.c
  group CryptoAuthlib
    ../ATSHA204/lib/: atca_command.c
    ../ATSHA204/lib/basic/: atca_basic.c
    ../ATSHA204/lib/crypto/: atca_crypto_sw_sha2.c
    ../ATSHA204/lib/crypto/hashes/: sha2_routines.c
    ../ATSHA204/lib/host/: atca_host.c
  group ATSHA204iface
    ../ATSHA204/lib/iface/: atca_iface_stm32_i2c.c atca_iface_stm32_swi.c
    ../ATSHA204/lib/hal/: hal_stm32_timer.c
  group BSP
    ../ATSHA204/Appatsha204/: atsha204a.c
    ../Src/: aw9136.c iap.c myiic.c oled.c timer.c stmflash.c sys.c Sha256.lib
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_crc.c
  group Application/User
    ../Src/: usb_device.c stm32f4xx_it.c usbd_custom_hid_if.c usbd_conf.c main.c usbd_desc.c stm32f4xx_hal_msp.c forPrintf.c
software components: CMSIS:CORE 4.1.0
