# Keil uVision project neo.uvprojx, settings and files
target neo Configuration (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: neo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\OBJ\neo.bin .\OBJ\neo.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc;..\..\Cpp;..\..\STM32_Cryptographic_Library\inc;..\..\Algorithm;..\..\ATSHA204\Appatsha204;..\..\ATSHA204\Atsha204_hw;..\..\ATSHA204\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c usb_device.c usbd_desc.c usbd_conf.c usbd_custom_hid_if.c
    ../../Cpp/: forPrintf.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_crc.c stm32f4xx_hal_rng.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Cpp
    ../../Cpp/: OLED.c DisplayMem.cpp Hal.cpp irq_handler.cpp myMain.cpp Commands.cpp ReceiveAnalysis.cpp Utils.cpp Sha256.lib PrivateKey.cpp PublicKey.cpp
    ../../Cpp/fingerPrint/: FingerPrintPacket.cpp FingerUtil.cpp
  group Algorithm
    ../../Algorithm/: Algorithm.c bignum.c encrypt.c getaddress.c ripemd160.c showsign.c
  group App
    ../../Algorithm/: stmflash.c aw9136.c myiic.c app_interface.c timer.c
    ../../Cpp/OLED281/: oled281.c
    ../../ATSHA204/Appatsha204/: atsha204a.c
  group ATSHA204_HW
    ../../ATSHA204/Atsha204_hw/: bitBang_i2c.c hw_config.c
  group CryptoAuthlib
    ../../ATSHA204/lib/: atca_command.c
    ../../ATSHA204/lib/basic/: atca_basic.c
    ../../ATSHA204/lib/crypto/: atca_crypto_sw_sha2.c
    ../../ATSHA204/lib/crypto/hashes/: sha2_routines.c
    ../../ATSHA204/lib/host/: atca_host.c
  group ATSHA204iface
    ../../ATSHA204/lib/iface/: atca_iface_stm32_i2c.c atca_iface_stm32_swi.c
    ../../ATSHA204/lib/hal/: hal_stm32_timer.c
